# Keil uVision project Project.uvprojx, settings and files
target ECG_Skeleton_F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECG_Skeleton +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\App\Main;..\..\App\DataType;..\..\App\PackUnpack;..\..\App\ProcHostCmd;..\..\App\SendDataToHost;..\..\HW\RCC;..\..\HW\Timer;..\..\HW\UART1;..\..\HW\ADC;..\..\HW\LED;..\..\ARM\NVIC;..\..\ARM\SysTick;..\..\Alg;..\..\module;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group APP
    ../../App/Main/: Main.c
    ../../App/ProcHostCmd/: ProcHostCmd.c
    ../../App/PackUnpack/: PackUnpack.c
    ../../App/SendDataToHost/: SendDataToHost.c
  group ALG
    ../../Alg/: ecg_filter.c ecg_coeffs.c ecg_heart.c ecg_leadoff.c
  group HW
    ../../HW/RCC/: RCC.c
    ../../HW/Timer/: Timer.c
    ../../HW/UART1/: UART1.c Queue.c
    ../../HW/ADC/: ADC.c U16Queue.c
    ../../HW/LED/: LED.c
  group ARM
    ../../ARM/NVIC/: NVIC.c
    ../../ARM/SysTick/: SysTick.c
  group MODULE
    ../../module/: stm32f4xx_it.c
  group CMSIS
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c
